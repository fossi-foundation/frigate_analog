v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {Placeholder for sky130_fd_io__top_pwrdetv2 schematic} -90 -70 0 0 0.4 0.4 {}
C {devices/iopin.sym} 0 20 0 1 {name=p1 lab=vccd}
C {devices/ipin.sym} 0 200 0 0 {name=p2 lab=in1_vddd_hv}
C {devices/opin.sym} 200 110 0 0 {name=p3 lab=out1_vddd_hv}
C {devices/iopin.sym} 0 40 0 1 {name=p4 lab=vddd1}
C {devices/iopin.sym} 0 60 0 1 {name=p5 lab=vddd2}
C {devices/iopin.sym} 0 80 0 1 {name=p6 lab=vddio_q}
C {devices/iopin.sym} 0 100 0 1 {name=p7 lab=vssa}
C {devices/iopin.sym} 0 120 0 1 {name=p8 lab=vssd}
C {devices/iopin.sym} 0 140 0 1 {name=p9 lab=vssio_q}
C {devices/ipin.sym} 0 220 0 0 {name=p10 lab=in1_vddio_hv}
C {devices/ipin.sym} 0 240 0 0 {name=p11 lab=in2_vddd_hv}
C {devices/ipin.sym} 0 260 0 0 {name=p12 lab=in2_vddio_hv}
C {devices/ipin.sym} 0 280 0 0 {name=p13 lab=in3_vddd_hv}
C {devices/ipin.sym} 0 300 0 0 {name=p14 lab=in3_vddio_hv}
C {devices/ipin.sym} 0 320 0 0 {name=p15 lab=rst_por_hv_n}
C {devices/opin.sym} 200 130 0 0 {name=p16 lab=out1_vddio_hv}
C {devices/opin.sym} 200 150 0 0 {name=p17 lab=out2_vddd_hv}
C {devices/opin.sym} 200 190 0 0 {name=p19 lab=out3_vddd_hv}
C {devices/opin.sym} 200 290 0 0 {name=p21 lab=vddd_present_vddio_hv}
C {devices/opin.sym} 200 310 0 0 {name=p22 lab=vddio_present_vddd_hv}
C {devices/opin.sym} 200 250 0 0 {name=p23 lab=tie_lo_esd}
C {devices/opin.sym} 200 170 0 0 {name=p18 lab=out2_vddio_hv}
C {devices/opin.sym} 200 210 0 0 {name=p20 lab=out3_vddio_hv}
